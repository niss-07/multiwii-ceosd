# Keil uVision project eosd.uvproj, settings and files
target Easy-OSD (ARM-ADS)
  device: STM32F101C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: eosd +hex
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\lib\STM32F10x_StdPeriph_Driver\inc;.\main;.\lib\CMSIS\CM3\CoreSupport;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./startup/: startup_stm32f10x_md.s
  group main
    ./main/: main.c stm32f10x_it.c system_stm32f10x.c SPI_MAX7456.c USART.c adc.c button.c led.c Retarget.c SysTick.c screen.c multiwii21.c
  group lib
    ./lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
